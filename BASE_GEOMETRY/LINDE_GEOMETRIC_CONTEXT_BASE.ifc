Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: R02 luminaire L2-012 | L2 square panel symbol proxy.001:363034
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0149
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-013 | L2 square panel symbol proxy.001:363035
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0150
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-001 | L3 round symbol proxy.001:363036
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0151
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-002 | L3 round symbol proxy.001:363037
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0152
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-003 | L3 round symbol proxy.001:363038
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0153
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-004 | L3 round symbol proxy.001:363039
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0154
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-005 | L3 round symbol proxy.001:363040
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0155
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-006 | L3 round symbol proxy.001:363041
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0156
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-007 | L3 round symbol proxy.001:363042
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0157
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-008 | L3 round symbol proxy.001:363043
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0158
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-009 | L3 round symbol proxy.001:363044
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0159
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-010 | L3 round symbol proxy.001:363045
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0160
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-011 | L3 round symbol proxy.001:363046
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0161
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-012 | L3 round symbol proxy.001:363047
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0162
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-013 | L3 round symbol proxy.001:363048
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0163
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-014 | L3 round symbol proxy.001:363049
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0164
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-015 | L3 round symbol proxy.001:363050
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0165
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-016 | L3 round symbol proxy.001:363051
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0166
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-017 | L3 round symbol proxy.001:363052
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0167
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-018 | L3 round symbol proxy.001:363053
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0168
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-019 | L3 round symbol proxy.001:363054
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0169
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-020 | L3 round symbol proxy.001:363055
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0170
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-021 | L3 round symbol proxy.001:363056
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0171
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-022 | L3 round symbol proxy.001:363057
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0172
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-023 | L3 round symbol proxy.001:363058
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0173
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-024 | L3 round symbol proxy.001:363059
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0174
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-025 | L3 round symbol proxy.001:363060
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0175
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-026 | L3 round symbol proxy.001:363061
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0176
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-027 | L3 round symbol proxy.001:363062
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0177
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-028 | L3 round symbol proxy.001:363063
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0178
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-029 | L3 round symbol proxy.001:363064
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0179
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-030 | L3 round symbol proxy.001:363065
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0180
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-031 | L3 round symbol proxy.001:363066
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0181
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-032 | L3 round symbol proxy.001:363067
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0182
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-033 | L3 round symbol proxy.001:363068
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0183
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-034 | L3 round symbol proxy.001:363069
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0184
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-035 | L3 round symbol proxy.001:363070
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0185
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L3-036 | L3 round symbol proxy.001:363071
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0186
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S07 | 01.001:363072
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0187
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S07 | 02.001:363073
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0188
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S07 | 03.001:363074
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0189
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S07 | 04.001:363075
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0190
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S07 | 05.001:363076
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0191
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S07 | 06.001:363077
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0192
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 01.001:363078
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0193
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 02.001:363079
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0194
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 03.001:363080
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0195
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 04.001:363081
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0196
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 05.001:363082
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0197
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 06.001:363083
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0198
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 07.001:363084
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0199
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S11 | 08.001:363085
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0200
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 01.001:363086
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0201
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 02.001:363087
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0202
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 03.001:363088
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0203
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 04.001:363089
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0204
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 05.001:363090
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0205
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 06.001:363091
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0206
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 07.001:363092
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0207
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 meeting chair | S12 | 08.001:363093
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0208
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 shared tabletop | S07 | DF174.001:363094
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0209
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 shared tabletop | S11 | DF1CC.001:363095
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0210
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 shared tabletop | S12 | DF133.001:363096
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0211
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 32.001:363097
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0212
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4767.001:363098
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0213
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 478F.001:363099
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0214
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4794.001:363100
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0215
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4798.001:363101
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0216
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 47F6.001:363102
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0217
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48A1.001:363103
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0218
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48A2.001:363104
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0219
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48A3.001:363105
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0220
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48A4.001:363106
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0221
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48A5.001:363107
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0222
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48CC.001:363108
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0223
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48CD.001:363109
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0224
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48CE.001:363110
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0225
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48CF.001:363111
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0226
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48D0.001:363112
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0227
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48D1.001:363113
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0228
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48DA.001:363114
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0229
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48E3.001:363115
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0230
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48EC.001:363116
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0231
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48F5.001:363117
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0232
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 48FE.001:363118
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0233
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4922.001:363119
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0234
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4923.001:363120
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0235
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4924.001:363121
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0236
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4925.001:363122
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0237
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4926.001:363123
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0238
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4927.001:363124
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0239
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4928.001:363125
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0240
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 4929.001:363126
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0241
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 492A.001:363127
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0242
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 492B.001:363128
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0243
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 492C.001:363129
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0244
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | 492D.001:363130
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0245
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | DF133.001:363131
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0246
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | DF174.001:363132
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0247
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | DF1CC.001:363133
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0248
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | DF2ED.001:363134
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0249
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 table supports | DF2EF.001:363135
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0250
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4765.001:363136
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0251
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4768.001:363137
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0252
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 476A.001:363138
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0253
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 476E.001:363139
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0254
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4770.001:363140
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0255
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4772.001:363141
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0256
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4774.001:363142
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0257
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4776.001:363143
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0258
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4778.001:363144
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0259
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4792.001:363145
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0260
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4796.001:363146
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0261
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 479A.001:363147
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0262
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48AA.001:363148
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0263
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48AC.001:363149
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0264
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48AE.001:363150
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0265
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48B4.001:363151
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0266
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48B6.001:363152
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0267
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48BC.001:363153
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0268
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48BE.001:363154
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0269
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48C4.001:363155
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0270
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48C6.001:363156
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0271
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48D2.001:363157
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0272
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48D4.001:363158
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0273
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48DB.001:363159
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0274
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48DD.001:363160
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0275
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48E4.001:363161
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0276
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48E6.001:363162
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0277
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48ED.001:363163
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0278
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48EF.001:363164
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0279
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48F6.001:363165
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0280
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48F8.001:363166
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0281
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 48FF.001:363167
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0282
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 task chair | 4901.001:363168
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0283
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 urinal | UR-S03-01.001:363169
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0284
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 urinal | UR-S03-02.001:363170
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0285
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S03-01.001:363171
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0286
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S03-02.001:363172
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0287
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S04-01.001:363173
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0288
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S04-02.001:363174
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0289
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S05-01.001:363175
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0290
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S05-02.001:363176
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0291
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S09-01.001:363177
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0292
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 wash basin | BA-S10-01.001:363178
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0293
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R11 | Kitchenette quartz packer frame around K1:363179
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0294
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R14 - floor display - neutral grey - surface only:363192, R15 - floor display - neutral grey - surface only
In: Level 1
Description: R15 conceptual finish-display mesh copied from reopened R15 Blender model; display assumption only.
Other - Category: Generic Models
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R14 - floor display - unmapped neutral - surface only:363194, R15 - floor display - unmapped neutral - surface only
In: Level 1
Description: R15 conceptual finish-display mesh copied from reopened R15 Blender model; display assumption only.
Other - Category: Generic Models
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R14 - floor display - wood appearance - surface only:363190, R15 - floor display - wood appearance - surface only
In: Level 1
Description: R15 conceptual finish-display mesh copied from reopened R15 Blender model; display assumption only.
Other - Category: Generic Models
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>
