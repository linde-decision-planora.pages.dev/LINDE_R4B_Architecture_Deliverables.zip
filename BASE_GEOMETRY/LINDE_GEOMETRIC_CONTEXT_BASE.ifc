Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 04474d6e-bac7-4465-863f-490e961b83de, VersionGUID: 37c93342-251e-4db5-9332-f1aab05f6106, NumberOfSaves: 7]
File name: LINDE_R14_CONCEPTUAL_R14.ifc
Time: 2026-10-05T21:37:02-05:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 27.2.0.39 (ENU) - 27.2.0.39

# IfcProject, LINDE R15 Conceptual Pre-Render
LongName: LINDE office reconstruction - conceptual study; Phase: Conceptual | CEO technical review | NOT FOR CONSTRUCTION

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Project Address: Arequipa, Peru - exact site unverified; Project Name: LINDE office reconstruction - conceptual study; Project Number: LINDE-R14; Project Status: Conceptual | CEO technical review | NOT FOR CONSTRUCTION
Identity Data - Author: PLANORA | Architecture and BIM; Building Name: LINDE historical source label | site unverified; Organization Description: Conceptual reconstruction from historical materials; not for construction.; Organization Name: PLANORA

# IfcBuilding, LINDE historical source label | site unverified
LongName: LINDE historical source label | site unverified
Other - Category: Project Information; Project Address: Arequipa, Peru - exact site unverified; Project Name: LINDE office reconstruction - conceptual study; Project Number: LINDE-R14; Project Status: Conceptual | CEO technical review | NOT FOR CONSTRUCTION
Identity Data - Author: PLANORA | Architecture and BIM; Building Name: LINDE historical source label | site unverified; Organization Description: Conceptual reconstruction from historical materials; not for construction.; Organization Name: PLANORA

# IfcBuildingStorey (2)
In: LINDE historical source label | site unverified
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
IFC Parameters - Export to IFC: By Type
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
IFC Parameters(Type) - Export Type to IFC: Default
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 32.001:362886
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0001
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4767.001:362887
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0002
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48A1.001:362888
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0003
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48A2.001:362889
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0004
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48A3.001:362890
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0005
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48A4.001:362891
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0006
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48A5.001:362892
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0007
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48CC.001:362893
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0008
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48CD.001:362894
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0009
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48CE.001:362895
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0010
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48CF.001:362896
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0011
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48D0.001:362897
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0012
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48D1.001:362898
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0013
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48DA.001:362899
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0014
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48E3.001:362900
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0015
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48EC.001:362901
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0016
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48F5.001:362902
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0017
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 48FE.001:362903
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0018
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4922.001:362904
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0019
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4923.001:362905
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0020
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4924.001:362906
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0021
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4925.001:362907
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0022
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4926.001:362908
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0023
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4927.001:362909
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0024
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4928.001:362910
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0025
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 4929.001:362911
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0026
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 492A.001:362912
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0027
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 492B.001:362913
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0028
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 492C.001:362914
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0029
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | E1 | SRC 492D.001:362915
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0030
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | EG | SRC 47F6.001:362916
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0031
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | EJ 2 | SRC 4794.001:362917
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0032
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | EJ1 | SRC 478F.001:362918
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0033
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 TABLETOP | EJ3 | SRC 4798.001:362919
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0034
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 floor | source outline with planter exclusion | 0.05 m dis:362920
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0035
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 01 | DAA3E.001:362921
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0036
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 02 | DAA3F.001:362922
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0037
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 03 | DAA40.001:362923
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0038
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 04 | DAA55.001:362924
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0039
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 05 | DAA56.001:362925
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0040
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 06 | DAA88.001:362926
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0041
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 07 | DAA89.001:362927
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0042
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 08 | DAA8A.001:362928
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0043
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 09 | DAA8B.001:362929
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0044
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 10 | DAA8C.001:362930
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0045
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 11 | DAA8D.001:362931
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0046
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 12 | DAA8E.001:362932
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0047
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 13 | DAA8F.001:362933
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0048
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 14 | DAAA1.001:362934
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0049
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 15 | DAAA2.001:362935
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0050
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 16 | DAAA3.001:362936
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0051
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 17 | DAAA4.001:362937
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0052
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R01 wall footprint 18 | DAB0C.001:362938
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0053
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 AC-01 indoor unit | S01 candidate | schematic.001:362939
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0054
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 AC-01 outdoor unit | adjacent exterior candidate | schemat:362940
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0055
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S03-01.001:362941
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0056
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S03-02.001:362942
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0057
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S04-01.001:362943
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0058
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S05-01.001:362944
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0059
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S05-02.001:362945
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0060
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S09-01.001:362946
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0061
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 WC | WC-S10-01.001:362947
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0062
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA81.001:362948
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0063
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA90.001:362949
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0064
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA91.001:362950
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0065
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA92.001:362951
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0066
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA93.001:362952
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0067
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA94.001:362953
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0068
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA95.001:362954
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0069
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA96.001:362955
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0070
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA97.001:362956
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0071
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA98.001:362957
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0072
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA99.001:362958
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0073
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA9A.001:362959
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0074
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA9B.001:362960
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0075
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA9C.001:362961
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0076
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA9D.001:362962
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0077
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA9E.001:362963
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0078
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAA9F.001:362964
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0079
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAAA0.001:362965
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0080
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 door leaf | DAAC8.001:362966
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0081
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 general ceiling plane | H02 3.00m assumed | extent concept:362967
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0082
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-E01.001:362968
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0083
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-E02.001:362969
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0084
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-N01.001:362970
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0085
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-N02.001:362971
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0086
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-W01.001:362972
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0087
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-W02.001:362973
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0088
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-W03.001:362974
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0089
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-W04.001:362975
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0090
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 glazing | G-W05.001:362976
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0091
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 inferred Es1 tabletop | DF2ED.001:362977
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0092
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 inferred Es1 tabletop | DF2EF.001:362978
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0093
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 kitchenette base cabinets | assumed 2.00m run.001:362979
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0094
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 kitchenette quartz counter | 15mm.001:362980
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0095
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 kitchenette sink | K1.001:362981
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0096
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 kitchenette splashback | extent assumed.001:362982
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0097
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 kitchenette upper cabinets | assumed run.001:362983
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0098
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-001 | L1 linear panel display proxy.001:362984
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0099
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-002 | L1 linear panel display proxy.001:362985
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0100
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-003 | L1 linear panel display proxy.001:362986
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0101
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-004 | L1 linear panel display proxy.001:362987
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0102
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-005 | L1 linear panel display proxy.001:362988
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0103
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-006 | L1 linear panel display proxy.001:362989
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0104
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-007 | L1 linear panel display proxy.001:362990
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0105
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-008 | L1 linear panel display proxy.001:362991
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0106
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-009 | L1 linear panel display proxy.001:362992
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0107
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-010 | L1 linear panel display proxy.001:362993
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0108
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-011 | L1 linear panel display proxy.001:362994
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0109
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-012 | L1 linear panel display proxy.001:362995
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0110
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-013 | L1 linear panel display proxy.001:362996
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0111
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-014 | L1 linear panel display proxy.001:362997
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0112
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-015 | L1 linear panel display proxy.001:362998
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0113
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-016 | L1 linear panel display proxy.001:362999
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0114
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-017 | L1 linear panel display proxy.001:363000
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0115
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-018 | L1 linear panel display proxy.001:363001
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0116
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-019 | L1 linear panel display proxy.001:363002
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0117
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-020 | L1 linear panel display proxy.001:363003
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0118
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-021 | L1 linear panel display proxy.001:363004
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0119
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-022 | L1 linear panel display proxy.001:363005
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0120
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-023 | L1 linear panel display proxy.001:363006
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0121
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-024 | L1 linear panel display proxy.001:363007
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0122
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-025 | L1 linear panel display proxy.001:363008
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0123
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-026 | L1 linear panel display proxy.001:363009
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0124
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-027 | L1 linear panel display proxy.001:363010
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0125
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-028 | L1 linear panel display proxy.001:363011
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0126
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-029 | L1 linear panel display proxy.001:363012
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0127
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-030 | L1 linear panel display proxy.001:363013
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0128
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-031 | L1 linear panel display proxy.001:363014
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0129
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-032 | L1 linear panel display proxy.001:363015
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0130
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-033 | L1 linear panel display proxy.001:363016
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0131
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-034 | L1 linear panel display proxy.001:363017
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0132
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-035 | L1 linear panel display proxy.001:363018
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0133
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-036 | L1 linear panel display proxy.001:363019
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0134
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-037 | L1 linear panel display proxy.001:363020
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0135
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-038 | L1 linear panel display proxy.001:363021
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0136
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L1-039 | L1 linear panel display proxy.001:363022
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0137
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-001 | L2 square panel symbol proxy.001:363023
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0138
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-002 | L2 square panel symbol proxy.001:363024
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0139
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-003 | L2 square panel symbol proxy.001:363025
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0140
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-004 | L2 square panel symbol proxy.001:363026
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0141
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-005 | L2 square panel symbol proxy.001:363027
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0142
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-006 | L2 square panel symbol proxy.001:363028
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0143
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-007 | L2 square panel symbol proxy.001:363029
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0144
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-008 | L2 square panel symbol proxy.001:363030
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0145
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-009 | L2 square panel symbol proxy.001:363031
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0146
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-010 | L2 square panel symbol proxy.001:363032
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0147
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-011 | L2 square panel symbol proxy.001:363033
In: Level 1
Other - Category: Generic Models
Identity Data - Comments: Conceptual; not for construction; units: m; local architectural frame; no CRS or north.; Mark: LINDE-R12-M0148
IFC Parameters - Export to IFC: By Type
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover 1 <25 mm>

# IfcBuildingElementProxy: R02 luminaire L2-012 | L2 square panel symbol proxy.001:363034
In: Level 1
